# IAR project lcd_ILI9341.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.PreInclude: ..\Inc\global.h
  ICCARM.CCIncludePath2: ..\Src; ..\Inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\..\..\Utilities\Third_Party\FreeRTOS\Source; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\MemMang; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\include; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s startup_stm32f40_41xxx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f427_437xx.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
  group FreeRTOS
    ../../../Utilities/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32F4xx_StdPeriph_Driver
    $EW_DIR$/arm/inc/c/: cmsis_iar.h
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../Src/: freertos.c functions.c main.c stm32f4xx_it.c XPT2046.c
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c
