# Keil uVision project lcd_320x240.uvprojx, settings and files
target lcd_320x240 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lcd_320x240 +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: ..\stm32f4xx_library\inc;.\user;C:\Keil_v5\ARM\INC\ST\STM32F4xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group mdk_arm
    ./: startup_stm32f4xx.s
  group stm32f4xx_stdperiph_driver
    ../stm32f4xx_library/src/: stm32f4xx_spi.c stm32f4xx_exti.c misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c
  group user
    ./user/: ts.c fonts.c LCD_STM32F4.c main.c pwm.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h functions.c
