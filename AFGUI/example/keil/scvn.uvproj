# Keil uVision project scvn.uvproj, settings and files
target test (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, TNKERNEL_PORT_CORTEXM4F
  c include: .\TNKernel\CortexM4F;.\TNKernel;.\user;.\StdLib\CMSIS\CoreSupport;.\StdLib\STM32F4xx_StdPeriph_Driver\inc;.\StdLib\CMSIS\STM32F4xx\Include;.\StdLib\CMSIS\STM32F4xx\Source\Templates\arm;.\bspStdLib\inc;.\..\..\wigets\inc;.\..\..\GUICore\inc;.\..\..\driver\inc;.\..\..\utils\inc;.\appGUI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group TNKernel
    ./TNKernel/CortexM4F/: tn_port_cm4f.c
    ./TNKernel/: tn.c tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_sem.c tn_tasks.c tn_utils.c
  group StdLib_F4
    ./StdLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group GUI
    ./../../driver/src/: lcdHAL_universal.c lcdHAL_ILI9320.c lcdHAL_HX8347A.c ee_emul.c beeper.c mkDriver_207Z.c ads7843_207Z.c
    ./../../GUICore/src/: guiColor.c guiPrimitives.c guiText.c widget.c guiFontsMin.c
    ./../../utils/src/: afTime.c
    ./../../wigets/src/: guiChart.c guiCheckBox.c guiLabel.c guiRadioGroup.c guiTextButton.c guiTouchCalibration.c guiUpDownBox.c
  group user
    ./user/: main.c tn_user.c hw_init.c
    ./StdLib/CMSIS/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group bspStdLib
    ./bspStdLib/src/: crcm.c button.c at26df.c uartdrv.c tn_task_usart.c
  group appGUI
    ./appGUI/: appGui.c HMI_Control.c winMain.c winUartCfg.c winPlot.c
